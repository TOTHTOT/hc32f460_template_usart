# Keil uVision project uart_irq_timeout.uvprojx, settings and files
target uart_irq_timeout_Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.8
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_irq_timeout
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32F460,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\source;..\common;..\driver\inc;..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ../common/: system_hc32f460keta.c
    ../common/cm_backtrace/: cm_backtrace.c
    ./: startup_hc32f460keta.s
  group source
    ../source/: main.c
  group Readme
    ../: Readme.txt
  group driver
    ../driver/src/: hc32f460_adc.c hc32f460_aes.c hc32f460_can.c hc32f460_clk.c hc32f460_cmp.c hc32f460_crc.c hc32f460_dcu.c hc32f460_dmac.c hc32f460_efm.c hc32f460_emb.c hc32f460_event_port.c hc32f460_exint_nmi_swi.c hc32f460_gpio.c hc32f460_hash.c hc32f460_i2c.c hc32f460_i2s.c hc32f460_icg.c hc32f460_interrupts.c hc32f460_keyscan.c hc32f460_mpu.c hc32f460_ots.c hc32f460_pwc.c hc32f460_qspi.c hc32f460_rmu.c hc32f460_rtc.c hc32f460_sdioc.c hc32f460_spi.c hc32f460_sram.c hc32f460_swdt.c hc32f460_timer0.c hc32f460_timer4_cnt.c hc32f460_timer4_emb.c hc32f460_timer4_oco.c hc32f460_timer4_pwm.c hc32f460_timer4_sevt.c hc32f460_timer6.c hc32f460_timera.c hc32f460_trng.c hc32f460_usart.c hc32f460_utility.c hc32f460_wdt.c
  group bsp
    ../bsp/src/: bsp_sys.c bsp_usart.c bsp_led.c
target uart_irq_timeout_Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.8
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_irq_timeout +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F460,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\..\mcu\common;..\source;..\..\..\..\..\driver\inc;..\..\..\..\..\bsp\ev_hc32f460_lqfp100_v2;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 4.3.0
